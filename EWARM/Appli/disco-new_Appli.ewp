# IAR project disco-new_Appli.ewp, settings and files
configuration disco-new_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../Appli/Core/Inc; ../../Secure_nsclib; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: disco-new_Appli.bin
  ILINK.IlinkOutputFile: disco-new_Appli.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx.s
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c secure_nsc.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_exti.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_ll_rcc.c stm32n6xx_ll_utils.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
