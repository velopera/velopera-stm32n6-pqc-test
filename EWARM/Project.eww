<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\disco-new_Appli.ewp</path>
  </project><project>
    <path>$WS_DIR$\FSBL\disco-new_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
